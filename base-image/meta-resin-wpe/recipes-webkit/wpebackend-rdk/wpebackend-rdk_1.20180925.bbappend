FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI += " \
	file://0002-WPEBackend-fix-wpe-version.patch \
          "
